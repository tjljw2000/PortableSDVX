# Keil uVision project PortableSDVX.uvproj, settings and files
target Target 1 (MCS-51)
  device: CH552 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: PortableSDVX +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 CH552.H CH552.INC Main.C Debug.C Debug.H Keymap.H USB.C USB.H WS2812.C WS2812.H
